# Keil uVision project clean.uvprojx, settings and files
target clean (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: clean +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/ENCODER;../User/PWM;../User/USART;../User/Grey;../User/Delay;../User/GW_gpio;../MDK-ARM;../User/KEY_EXTI;../User/OLED;../User/Buzzer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../User/PWM/: pwm.c pwm.h
    ../User/ENCODER/: encoder.c encoder.h
    ../User/Delay/: Delay.c Delay.h
    ../User/GW_gpio/: gw_grayscale_sensor.h GWKJ.c GWKJ.h
    ./: Imu.c Imu.h pid.c pid.h distance.c distance.h
    ../User/KEY_EXTI/: key.c key.h
    ../User/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
    ../User/Buzzer/: Buzzer.c Buzzer.h
    ../Core/Src/: system_stm32f4xx.c
    ../User/USART/: usart_2.c usart_2.h
software components: CMSIS:CORE 4.3.0
