# Keil uVision project 7.21.uvprojx, settings and files
target 7.21 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 7.21 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/Delay;../User/KEY_EXTI;../User/OLED;../User/Stepper_Motor;../User/USART;../User/YunTai;../MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ./: No_Mcu_Ganv_Grayscale_Sensor.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../User/Delay/: Delay.c Delay.h
    ../User/KEY_EXTI/: key.c key.h
    ../User/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
    ../User/Stepper_Motor/: Stepper_Motor.c Stepper_Motor.h
    ../User/YunTai/: yuntai.c yuntai.h
    ../User/USART/: serial_it_config.c serial_it_config.h usart_1.c usart_1.h usart_2.c usart_2.h usart_3.c usart_3.h
    ./: pid.c pid.h Bujin.c Bujin.h pid_2.c pid_2.h duoji.c duoji.h pid_duoji.c pid_duoji.h
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
